# Keil uVision project XRDS-Stm32.uvprojx, settings and files
target Stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XRDS-Stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\BSP\LED;..\BSP\USART;..\BSP\DELAY;..\BSP\FLASH;..\BSP\KEY;..\BSP\CAN;..\BSP\ADS1256;..\BSP\G6A
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32f10x_conf.h stm32f10x_it.c app_defines.h app_includes.h
  group BSP
    ../BSP/LED/: led.c
    ../BSP/DELAY/: delay.c
    ../BSP/USART/: usart1.c
    ../BSP/CAN/: can.c
    ../BSP/G6A/: g6a.c
    ../BSP/ADS1256/: ADS1256.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c
  group Doc
    ../Doc/: readme.txt
