# Keil uVision project XRDS-STM32.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: XRDS-STM32
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\APP;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\BSP\LED;..\BSP\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: app_defines.h app_includes.h main.c stm32f10x_conf.h stm32f10x_it.c
  group BSP
    ../BSP/LED/: led.c
    ../BSP/USART/: usart1.c
  group STARTUP
    ./: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Doc
    ../Doc/: readme.txt
